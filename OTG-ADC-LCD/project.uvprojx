# Keil uVision project project.uvprojx, settings and files
target STM32F4-Discovery (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY
  c include: .\User;..\TM;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-STM32F429_LIBRARIES;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\00-STM32F429_LIBRARIES\usb_cdc_device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Startup
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s startup_stm32f401xx.s startup_stm32f411xe.s startup_stm32f429_439xx.s
  group STD_Periph_Drivers
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_usart.c
  group TM
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_adc.h
    ../00-STM32F429_LIBRARIES/: tm_stm32f4_disco.h tm_stm32f4_disco.c tm_stm32f4_usb_vcp.c tm_stm32f4_usb_vcp.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_adc.c tm_stm32f4_adc.h tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_fonts.c tm_stm32f4_fonts.h tm_stm32f4_i2c.c tm_stm32f4_i2c.h tm_stm32f4_ili9341.c tm_stm32f4_ili9341.h tm_stm32f4_ili9341_button.c tm_stm32f4_ili9341_button.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_stmpe811.c tm_stm32f4_stmpe811.h tm_stm32f4_usart.c tm_stm32f4_usart.h
  group User
    ./User/: main.h main.c defines.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c main407.c ads1256.c ads1256.h
  group USB CDC Device
    ../00-STM32F429_LIBRARIES/usb_cdc_device/: usb_bsp.c usb_bsp.h usb_conf.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_defines.h usb_regs.h usbd_cdc_core.c usbd_cdc_core.h usbd_cdc_vcp.c usbd_cdc_vcp.h usbd_conf.h usbd_core.c usbd_core.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h usbd_req.c usbd_req.h usbd_usr.c usbd_usr.h
target STM32F429-Discovery (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F429_DISCOVERY,USE_USB_OTG_HS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Nucleo-F411 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_NUCLEO_F411
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Nucleo-F401 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_NUCLEO_F401
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
